Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-01-29T00:09:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 29 00:09:24 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8f60cd24-d351-4d47-92a9-e92f049f2c17\41f985a4-232d-4890-a5f0-8d26e3347f03\ifc * Database version: 5507 * Database creation date: Mon Jan 29 00:09:23 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 29 00:09:23 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 29 00:09:23 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 6104Q Washbasin faucet, 24/48 V, non-Bluetooth, 6104Q(2023):6104Q Washbasin faucet, 24/48 V, non-Bluetooth:94536
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - InletConnectionSize: 16 mm; NominalDepth: 163 mm; NominalHeight: 205 mm; NominalWidth: 51 mm
Type - Electrical - Bluetooth: No Bluetooth; Electrical Connection: 24-48V; Operating Voltage: 24 V; Protection Class: IP 67
Type - General - Author: BIMStone; BIMObjectName: 6104Q(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 17/01/2024
Type - Green Building Properties - EAN Number: 6414150105210; EMC Directive: Radio Equipment Directive 2014/53/EU , Low Voltage Directive 2014/35/EU , EMC Directive 2014/30/EU , RoHS Directive 2011/65/EU; EN Standard: EN 15091, ETSI EN 301 489-1 V1.9.2 , ETSI EN 300 328 v2.2.2 , EN 61000-6-1:2007 , EN 61000-6-3:2007+A1:2011+AC:2012 , EN 60335-1:2012+A11+A13+A1+A14+A2+A15:2021, Part 19.11.4; Sales Package dimensions (LxWxH): 696 x 320 x 88; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/6104Q; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/189452_6104Q_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL WEEE: http://static.oras.com/WEEE/6104Q
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/6104Q; Catalog Drawing URL: http://static.oras.com/catdrw/6104Q; Dimension Drawing URL: http://static.oras.com/dimdrw/6104Q; FDV Document URL: http://www.oras.com/datasheet/6104Q/en/fdv; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/6104Q; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Poland;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/6104Q; Model: 6104Q Washbasin faucet, 24/48 V, non-Bluetooth; Name_en: 6104Q Washbasin faucet, 24/48 V, non-Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 6104Q; Product Family: Oras Electra; Product Image URL: http://static.oras.com/image/6104Q; Product URL: http://static.oras.com/6104Q; Short Marketing: Touchless washbasin faucet with a mixing valve. Electrical connection 24/48 V. Recognition range can be adjusted at the faucet. The faucet is equipped with litter filters and non-return valves. (Oras No. 198081/m) 3 - 6 and 9 meters photocell cables available; Technical DataSheet URL: http://www.oras.com/datasheet/6104Q/en; Type Name: 6104Q Washbasin faucet, 24/48 V, non-Bluetooth; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Aerator: Standard aerator; Afterflow Period: 3 s (1-20 s); Automatic Flush Frequency: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Connection: Flexible inlet pipes; Electronic Parts: Infrared sensor;Solenoid valve; Installation Type: Deck mounted; Lever Handle: Temperature control handle; Max Flow Period: 2 min (1 - 1800 s); Mechanical Parts: Mixing valve for manual temperature control;Non-return valve(s);Litter filter(s); Mounting Holes: 1 hole; Operating Distance: 0-130 mm (0-400 mm); Spout Type: Fixed spout;Casted construction; Surface treatment: Chrome
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6104Q(2023); Features: Touchless;External transformer; Finish: Polished; Grade: n/a; ModelNumber: n/a; ModelReference: 6104Q; Name: 6104Q Washbasin faucet, 24/48 V, non-Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 50x165x205 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.054093 m2; Volume: 0.00171623 m3
Identity Data - Mark: 40
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 6104Q(2023): 6104Q Washbasin faucet, 24/48 V, non-Bluetooth; Family and Type: 6104Q(2023): 6104Q Washbasin faucet, 24/48 V, non-Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6104Q(2023): 6104Q Washbasin faucet, 24/48 V, non-Bluetooth; Type Id: 6104Q(2023): 6104Q Washbasin faucet, 24/48 V, non-Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
